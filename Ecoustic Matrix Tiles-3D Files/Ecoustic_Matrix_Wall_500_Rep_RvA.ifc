Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2018-05-08T11:55:37
Author: Maxwell Madden
Organization: Instyle
Made in: ASIFC - 2.9.0.819

# IfcProject
LongName: Ecoustic_Wall_Matrix_500_Rep_RvB

# IfcSite, Site
RefLatitude: 47, 35, 59, 994506; RefLongitude: -122, -17, -59, -983520; RefElevation: 0 mm

# IfcProxy
ProxyType: PRODUCT
